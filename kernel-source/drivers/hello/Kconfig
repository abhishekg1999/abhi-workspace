## kernel-source/drivers/hello/Kconfig
```kconfig
config HELLO_WORLD
	tristate "hello world module"
	default m
	help
	simple hello world module.
	print massage on load and unload.
```
